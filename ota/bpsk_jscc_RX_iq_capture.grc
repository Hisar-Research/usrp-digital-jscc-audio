options:
  parameters:
    author: amr
    description: 'RX-stable B210 flowgraph: RX AGC enabled, 8192-bit acquisition + 4096-bit sync, hard sync <=1840 errors, balanced soft rescue <=1900 with normalized soft correlation >=0.12. Designed to reduce orphan/false payload detections while preserving low-SNR rescue.'
    generate_options: qt_gui
    id: untitled1
    output_language: python
    title: BPSK JSCC RX-Stable - AGC ON + 8192 Acquisition + Balanced Soft Rescue
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    comment: Loop bandwidth for the Costas loop. Wider = faster/more reliable pull-in within the 1024-bit acquisition preamble (fewer 'still spinning at sync time' bursts) but noisier once locked. Narrower = cleaner once locked but more bursts may fail to converge in time. Watch how the LONG SYNC DETECTED errors= distribution shifts as you sweep this.
    label: Costas Loop BW
    start: '0.01'
    step: '0.005'
    stop: '0.3'
    value: '0.0628'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '100'
    value: '30'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: RX AGC is enabled in the USRP Source, so this manual rx_gain control is ignored while AGC remains enabled.
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 50e3
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_preamble
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Tags each 1536-byte ultra-long preamble as one packet (8192 acquisition bits + 4096 sync bits).
    len_tag_key: packet_len
    packet_len: '1536'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '32'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: 'Input 0: 1536-byte preamble (8192-bit acquisition + 4096-bit sync); input 1: 12-byte GNU framing; input 2: fixed RF payload.'
    lengthtagname: packet_len
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_vector_source_preamble
  id: blocks_vector_source_x
  parameters:
    comment: '1536-byte low-SNR preamble: 8192 acquisition bits of 1 followed by the same 4096-bit pseudo-random sync. The 4096-bit suffix is the actual RX detector.'
    repeat: 'True'
    type: byte
    vector: '[255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 255, 87, 85, 58, 248, 202, 108, 88, 112, 112, 59, 85, 81, 194, 206, 75, 147, 229, 149, 58, 106, 121, 96, 72, 162, 35, 246, 62, 90, 139, 245, 21, 234, 101, 206, 79, 244, 135, 199, 182, 232, 215, 254, 85, 134, 76, 171, 96, 122, 238, 127, 97, 188, 197, 223, 145, 213, 128, 120, 107, 153, 112, 45, 65, 208, 136, 84, 109, 84, 243, 55, 125, 43, 239, 105, 152, 35, 193, 92, 10, 205, 232, 77, 23, 189, 1, 29, 136, 79, 139, 86, 237, 231, 53, 15, 133, 224, 206, 195, 109, 4, 242, 201, 224, 128, 245, 190, 194, 69, 141, 217, 101, 197, 6, 165, 139, 231, 252, 253, 191, 170, 151, 85, 213, 124, 47, 177, 64, 47, 140, 43, 58, 8, 157, 102, 34, 160, 108, 46, 164, 143, 23, 211, 132, 14, 2, 195, 200, 150, 38, 223, 143, 225, 186, 97, 92, 246, 177, 163, 80, 103, 116, 12, 128, 98, 178, 189, 180, 98, 179, 223, 140, 213, 214, 252, 231, 250, 206, 164, 237, 28, 6, 106, 230, 239, 46, 171, 176, 110, 12, 111, 193, 16, 214, 135, 81, 38, 105, 202, 247, 163, 80, 142, 178, 138, 113, 34, 148, 149, 162, 123, 29, 231, 39, 139, 83, 223, 167, 14, 4, 129, 65, 3, 139, 167, 65, 120, 211, 47, 86, 100, 17, 237, 29, 112, 237, 199, 85, 252, 63, 145, 236, 168, 118, 106, 51, 83, 235, 241, 14, 75, 27, 234, 56, 77, 59, 9, 162, 50, 189, 158, 52, 239, 198, 210, 141, 59, 226, 203, 68, 155, 78, 131, 228, 175, 90, 111, 217, 245, 197, 41, 159, 43, 193, 73, 241, 183, 141, 91, 205, 169, 59, 22, 24, 5, 119, 16, 72, 107, 145, 73, 10, 104, 250, 61, 47, 39, 127, 153, 95, 39, 206, 141, 186, 234, 59, 204, 171, 108, 242, 32, 152, 42, 163, 44, 100, 56, 170, 182, 69, 153, 68, 66, 165, 24, 101, 210, 126, 134, 99, 19, 21, 101, 120, 203, 112, 5, 3, 204, 161, 150, 144, 30, 178, 241, 183, 82, 66, 161, 177, 229, 172, 147, 155, 55, 170, 24, 48, 115, 241, 31, 191, 126, 213, 215, 159, 245, 84, 148, 51, 171, 112, 183, 127, 88, 161, 52, 118, 195, 221, 20, 13, 131, 252, 134, 8, 37, 49, 57, 166, 239, 2, 130, 7, 178, 65, 125, 238, 196, 245, 116, 205, 225, 23, 43, 255, 254, 185, 163, 95, 168, 111, 180, 2, 3, 167, 162, 159, 84, 238, 139, 246, 90, 228, 139, 255, 73, 41, 179, 111, 96, 66, 118, 105, 210, 0, 119, 32, 120, 145, 119, 117, 116, 29, 150, 211, 174, 25, 196, 141, 43, 172, 250, 252, 124, 0, 165, 70, 215, 68, 189, 194, 173, 200, 35, 103, 7, 237, 85, 250, 53, 230, 238, 161, 236, 141, 125, 126, 182, 102, 76, 152, 237, 46, 240, 159, 179, 78, 194, 141, 17, 92, 94, 185, 33, 35, 188, 115, 161, 180, 10, 174, 227]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: GNU Radio header_format_default supports access codes up to 64 bits. The long 256-bit acquisition preamble is inserted separately before this header.
    format: digital.header_format_default( "1010101011001101001011101000010111010011101101000110100011110010", 12, 1)
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: bpsk
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_dual_packet_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import array
      import struct

      class blk(gr.basic_block):
          """
          4096-bit low-SNR packet detector with soft-assisted acquisition.

          Input 0: differentially decoded hard bits (uint8)
          Input 1: aligned DBPSK soft metric (float32), negative=0, positive=1
          Input 2: same-symbol, post-Costas complex64 samples (not raw USRP IQ)

          Detection policy:
            1) hard accept when Hamming distance <= 1840/4096
            2) for 1841..1900 errors, accept only when normalized soft
               correlation with the known 4096-bit sync word is >= 0.10

          Packet extraction / UDP payload behavior is unchanged.
          """

          def __init__(self, skip_header_bits=96, plain_bytes=488,
                       soft_bits=3900, vogeo_bytes=488, sync_tag="unused"):
              gr.basic_block.__init__(
                  self,
                  name="4096-bit hard+soft low-SNR detector",
                  in_sig=[np.uint8, np.float32, np.complex64],
                  out_sig=[]
              )

              self.sync_bits = "0101011101010101001110101111100011001010011011000101100001110000011100000011101101010101010100011100001011001110010010111001001111100101100101010011101001101010011110010110000001001000101000100010001111110110001111100101101010001011111101010001010111101010011001011100111001001111111101001000011111000111101101101110100011010111111111100101010110000110010011001010101101100000011110101110111001111111011000011011110011000101110111111001000111010101100000000111100001101011100110010111000000101101010000011101000010001000010101000110110101010100111100110011011101111101001010111110111101101001100110000010001111000001010111000000101011001101111010000100110100010111101111010000000100011101100010000100111110001011010101101110110111100111001101010000111110000101111000001100111011000011011011010000010011110010110010011110000010000000111101011011111011000010010001011000110111011001011001011100010100000110101001011000101111100111111111001111110110111111101010101001011101010101110101010111110000101111101100010100000000101111100011000010101100111010000010001001110101100110001000101010000001101100001011101010010010001111000101111101001110000100000011100000001011000011110010001001011000100110110111111000111111100001101110100110000101011100111101101011000110100011010100000110011101110100000011001000000001100010101100101011110110110100011000101011001111011111100011001101010111010110111111001110011111111010110011101010010011101101000111000000011001101010111001101110111100101110101010111011000001101110000011000110111111000001000100001101011010000111010100010010011001101001110010101111011110100011010100001000111010110010100010100111000100100010100101001001010110100010011110110001110111100111001001111000101101010011110111111010011100001110000001001000000101000001000000111000101110100111010000010111100011010011001011110101011001100100000100011110110100011101011100001110110111000111010101011111110000111111100100011110110010101000011101100110101000110011010100111110101111110001000011100100101100011011111010100011100001001101001110110000100110100010001100101011110110011110001101001110111111000110110100101000110100111011111000101100101101000100100110110100111010000011111001001010111101011010011011111101100111110101110001010010100110011111001010111100000101001001111100011011011110001101010110111100110110101001001110110001011000011000000001010111011100010000010010000110101110010001010010010000101001101000111110100011110100101111001001110111111110011001010111110010011111001110100011011011101011101010001110111100110010101011011011001111001000100000100110000010101010100011001011000110010000111000101010101011011001000101100110010100010001000010101001010001100001100101110100100111111010000110011000110001001100010101011001010111100011001011011100000000010100000011110011001010000110010110100100000001111010110010111100011011011101010010010000101010000110110001111001011010110010010011100110110011011110101010000110000011000001110011111100010001111110111111011111101101010111010111100111111111010101010100100101000011001110101011011100001011011101111111010110001010000100110100011101101100001111011101000101000000110110000011111111001000011000001000001001010011000100111001101001101110111100000010100000100000011110110010010000010111110111101110110001001111010101110100110011011110000100010111001010111111111111111110101110011010001101011111101010000110111110110100000000100000001110100111101000101001111101010100111011101000101111110110010110101110010010001011111111110100100100101001101100110110111101100000010000100111011001101001110100100000000001110111001000000111100010010001011101110111010101110100000111011001011011010011101011100001100111000100100011010010101110101100111110101111110001111100000000001010010101000110110101110100010010111101110000101010110111001000001000110110011100000111111011010101010111111010001101011110011011101110101000011110110010001101011111010111111010110110011001100100110010011000111011010010111011110000100111111011001101001110110000101000110100010001010111000101111010111001001000010010001110111100011100111010000110110100000010101010111011100011"
              self.sync_len = len(self.sync_bits)
              self.sync_int = int(self.sync_bits, 2)
              self.sync_mask = (1 << self.sync_len) - 1

              # Conservative hard detector plus a soft-assisted rescue region.
              self.hard_threshold = 1840
              self.soft_candidate_threshold = 1900
              self.soft_score_threshold = 0.12

              # Expected bipolar sync symbols for the DBPSK soft metric:
              # bit 0 -> -1, bit 1 -> +1.
              self.sync_bipolar = np.fromiter(
                  (1.0 if c == "1" else -1.0 for c in self.sync_bits),
                  dtype=np.float32,
                  count=self.sync_len
              )

              self.skip_header_bits = int(skip_header_bits)
              self.fixed_bytes = int(plain_bytes)
              self.target_bits = self.fixed_bytes * 8
              self.soft_target_bits = int(soft_bits)

              self.out_port = pmt.intern("pdus")
              self.soft_out_port = pmt.intern("soft_pdus")
              self.iq_out_port = pmt.intern("iq_pdus")
              self.message_port_register_out(self.out_port)
              self.message_port_register_out(self.soft_out_port)
              self.message_port_register_out(self.iq_out_port)

              self.shiftreg = 0
              self.search_count = 0

              # Circular buffer holding the soft values aligned with the current
              # 4096-bit hard synchronization window.
              self.sync_soft_buf = np.zeros(self.sync_len, dtype=np.float32)
              self.sync_soft_write = 0

              self.state = "SEARCH"
              self.skip_left = 0

              self.buf = np.empty(self.target_bits, dtype=np.uint8)
              self.soft_buf = np.empty(self.target_bits, dtype=np.float32)
              self.iq_buf = np.empty(self.target_bits, dtype=np.complex64)
              self.pos = 0
              self.detections = 0

          def _reset_search(self):
              self.shiftreg = 0
              self.search_count = 0
              self.sync_soft_write = 0
              self.sync_soft_buf.fill(0.0)
              self.state = "SEARCH"
              self.skip_left = 0
              self.pos = 0

          def _soft_sync_score(self):
              # Convert the circular buffer into chronological order only for
              # candidate windows. Candidates are rare, so this does not burden
              # the normal streaming path.
              w = self.sync_soft_write
              if w == 0:
                  soft_window = self.sync_soft_buf
              else:
                  soft_window = np.concatenate(
                      (self.sync_soft_buf[w:], self.sync_soft_buf[:w])
                  )

              denom = float(np.sum(np.abs(soft_window)))
              if denom <= 1e-12:
                  return 0.0

              return float(np.dot(soft_window, self.sync_bipolar) / denom)

          def _start_packet(self, distance, mode, soft_score=None):
              self.state = "SKIP"
              self.skip_left = self.skip_header_bits
              self.pos = 0
              self.detections += 1

              if soft_score is None:
                  print(
                      "LONG SYNC DETECTED | "
                      f"mode={mode} | errors={distance}/4096 | "
                      f"hard_threshold={self.hard_threshold} | "
                      f"detection={self.detections}"
                  )
              else:
                  print(
                      "LONG SYNC DETECTED | "
                      f"mode={mode} | errors={distance}/4096 | "
                      f"soft_score={soft_score:.4f} | "
                      f"soft_threshold={self.soft_score_threshold:.3f} | "
                      f"detection={self.detections}"
                  )

          def _emit(self):
              packed = np.packbits(
                  self.buf[:self.target_bits],
                  bitorder="big"
              )

              if len(packed) != self.fixed_bytes:
                  print(
                      "INTERNAL LENGTH ERROR | "
                      f"got={len(packed)} expected={self.fixed_bytes}"
                  )
                  self._reset_search()
                  return

              vec = pmt.init_u8vector(len(packed), packed.tolist())
              self.message_port_pub(
                  self.out_port,
                  pmt.cons(pmt.PMT_NIL, vec)
              )

              # One detection number shared by the soft and IQ outputs.
              # SPK1: 4-byte magic, 32-bit network-order detection ID.
              detection_id = self.detections
              soft_bytes = struct.pack("!4sI", b"SPK1", detection_id) + (
                  self.soft_buf[:self.soft_target_bits].astype("<f4", copy=False).tobytes()
              )
              soft_vec = pmt.init_u8vector(len(soft_bytes), array.array("B", soft_bytes))
              self.message_port_pub(
                  self.soft_out_port,
                  pmt.cons(pmt.PMT_NIL, soft_vec)
              )

              # IQF1: 4-byte magic, uint32 detection ID, uint16 fragment
              # index, uint16 total fragments, uint32 complex sample count.
              # Small UDP datagrams avoid the 65507-byte IPv4 UDP limit.
              iq_bytes = self.iq_buf[:self.soft_target_bits].astype(
                  "<c8", copy=False
              ).tobytes()
              frag_size = 24000  # a multiple of complex64's 8 bytes
              frag_count = (len(iq_bytes) + frag_size - 1) // frag_size
              for part in range(frag_count):
                  fragment = iq_bytes[part * frag_size:(part + 1) * frag_size]
                  frame = struct.pack(
                      "!4sIHHI", b"IQF1", detection_id, part,
                      frag_count, self.soft_target_bits
                  ) + fragment
                  iq_vec = pmt.init_u8vector(len(frame), array.array("B", frame))
                  self.message_port_pub(
                      self.iq_out_port,
                      pmt.cons(pmt.PMT_NIL, iq_vec)
                  )

              print(
                  "RF PAYLOAD EMITTED | "
                  f"hard={len(packed)} bytes | "
                  f"soft={self.soft_target_bits} float32 values"
              )

              self._reset_search()

          def general_work(self, input_items, output_items):
              x = input_items[0]
              s = input_items[1]
              iq = input_items[2]
              n = min(len(x), len(s), len(iq))

              for idx in range(n):
                  bit = int(x[idx]) & 1
                  soft = float(s[idx])

                  if self.state == "SEARCH":
                      self.shiftreg = (
                          ((self.shiftreg << 1) | bit) & self.sync_mask
                      )

                      # Save the soft metric at exactly the same stream position.
                      self.sync_soft_buf[self.sync_soft_write] = soft
                      self.sync_soft_write += 1
                      if self.sync_soft_write >= self.sync_len:
                          self.sync_soft_write = 0

                      if self.search_count < self.sync_len:
                          self.search_count += 1

                      if self.search_count >= self.sync_len:
                          distance = (
                              self.shiftreg ^ self.sync_int
                          ).bit_count()

                          # Very safe hard decision.
                          if distance <= self.hard_threshold:
                              self._start_packet(distance, "hard")

                          # Rescue packets that are slightly too noisy for the hard
                          # detector only when confidence-weighted soft correlation
                          # also agrees with the known sync word.
                          elif distance <= self.soft_candidate_threshold:
                              score = self._soft_sync_score()
                              if score >= self.soft_score_threshold:
                                  self._start_packet(distance, "soft-rescue", score)

                      continue

                  if self.state == "SKIP":
                      self.skip_left -= 1
                      if self.skip_left <= 0:
                          self.state = "COLLECT"
                          self.pos = 0
                      continue

                  if self.state == "COLLECT":
                      self.buf[self.pos] = bit
                      self.soft_buf[self.pos] = soft
                      self.iq_buf[self.pos] = iq[idx]
                      self.pos += 1

                      if self.pos >= self.target_bits:
                          self._emit()

              self.consume(0, n)
              self.consume(1, n)
              self.consume(2, n)
              return 0
    comment: Hard+soft 4096-bit sync. For every fully detected packet sends SPK1 prefixed float32 soft PDU on UDP 5002 and IQF1 fragmented complex64 PDU on UDP 5003, same detection ID.
    plain_bytes: '1502'
    skip_header_bits: '96'
    soft_bits: '12016'
    sync_tag: '"unused"'
    vogeo_bytes: '1502'
  states: {}
- name: epy_dbpsk_soft
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Differential-BPSK soft metric (vectorized).

          Input: one complex symbol/sample per BPSK symbol after Symbol Sync + Costas.
          Output convention matches bipolar bits used by the neural classifier:
              negative -> bit 0
              positive -> bit 1
              magnitude -> confidence

          For DBPSK:
              soft[k] = -Re{ r[k] * conj(r[k-1]) }

          The initial previous symbol is constellation index 0 = -1, matching the
          differential encoder/decoder initial state used by the current flowgraph.

          Vectorized (no per-sample Python loop) so it can keep up with the USRP
          source at full sample rate without causing input overflows.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="DBPSK soft metric (-Re[r_k r*_{k-1}])",
                  in_sig=[np.complex64],
                  out_sig=[np.float32],
              )
              self.prev = np.complex64(-1.0 + 0.0j)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              n = len(x)
              if n == 0:
                  return 0

              prev_arr = np.empty(n, dtype=np.complex64)
              prev_arr[0] = self.prev
              if n > 1:
                  prev_arr[1:] = x[:-1]

              y[:] = -np.real(x * np.conj(prev_arr))
              self.prev = x[-1]
              return n
    comment: One soft value per differentially decoded BPSK bit. Negative=0, positive=1; magnitude is confidence.
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Receives ONLY the 376-byte coded payload from TX Python on UDP 5000.
    host: 127.0.0.1
    mtu: '10000'
    port: '5000'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    comment: 'Detected packets only: SPK1 (8-byte detection ID) followed by 12016 float32 soft values on UDP 5002.'
    host: 127.0.0.1
    mtu: '65000'
    port: '5002'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_iq
  id: network_socket_pdu
  parameters:
    comment: 'Detected packets only: IQF1 UDP fragments (complex64 after Costas), with shared detection counter. RX Python reconstructs and validates fragment count.'
    host: 127.0.0.1
    mtu: '30000'
    port: '5003'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(868e6, 500e3)
    dev_addr: '"serial=33559EA,send_frame_size=4096,num_send_frames=64"'
    gain0: gain
    len_tag_name: packet_len
    maxoutbuf: '262144'
    minoutbuf: '65536'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(868e6, -500e3)
    comment: RX AGC enabled as requested for low-SNR acquisition. Manual rx_gain is ignored while AGC is active. LO offset and large RX buffers retained.
    dev_addr: '"serial=3367F2F,recv_frame_size=4096,num_recv_frames=64"'
    iq_imbal_enb0: auto
    maxoutbuf: '262144'
    minoutbuf: '65536'
    rx_agc0: Enabled
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', epy_block_dual_packet_0, '1']
- [blocks_stream_to_tagged_stream_preamble, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_tagged_stream_multiply_length_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_preamble, '0', blocks_stream_to_tagged_stream_preamble, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_dual_packet_0, '2']
- [digital_costas_loop_cc_0, '0', epy_dbpsk_soft, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', epy_block_dual_packet_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_dual_packet_0, iq_pdus, network_socket_pdu_iq, pdus]
- [epy_block_dual_packet_0, soft_pdus, network_socket_pdu_0_0, pdus]
- [epy_dbpsk_soft, '0', blocks_multiply_const_vxx_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '2']
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [uhd_usrp_source_0_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
